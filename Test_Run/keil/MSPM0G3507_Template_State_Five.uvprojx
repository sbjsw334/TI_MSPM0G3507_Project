# Keil uVision project MSPM0G3507_Template_State_Five.uvprojx, settings and files
target MSPM0G3507_Template_State_Five (6160000::V6.16::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: MSPM0G3507_Template_State_Five +hex
  BeforeMake: cmd.exe /C "D:\TI\mspm0_sdk_2_00_01_00\tools\keil\syscfg.bat '$P' MSPM0G3507_Template_State_Five.syscfg"
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3507__
  c include: ..;..\Application;..\Board;..\BSP\inc;..\Hardware;D:\TI\mspm0_sdk_2_00_01_00\source\third_party\CMSIS\Core\Include;D:\TI\mspm0_sdk_2_00_01_00\source
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: ./mspm0g3507.sct
  link misc: D:\TI\mspm0_sdk_2_00_01_00\source\ti\driverlib\lib\keil\m0p\mspm0g1x0x_g3x0x\driverlib.a
  group Source
    ../: main.c MSPM0G3507_Template_State_Five.syscfg ti_msp_dl_config.h ti_msp_dl_config.c
    ./: startup_mspm0g350x_uvision.s
  group Board
    ../Board/: board.c
  group Application
    ../Application/: app_state_machine.c pid_ctrl.c msg_map.c sub_state_machine.c
  group BSP
    ../BSP/src/: bsp_motor.c bsp_encoder.c bsp_oled.c bsp_key.c bsp_led.c bsp_led_instances.c
  group Hardware
    ../Hardware/: mpu_port.c
  group README
    ../docs/: ARCHITECTURE.md
    ../: PINMAP.md README.md
